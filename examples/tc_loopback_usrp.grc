options:
  parameters:
    author: gr-soarr
    description: Transmits and receives on one USRP (TX/RX and RX2 ports, e.g. over a cable with attenuator) and checks the whole TC chain end to end. Switch between PLOP-1 (bursts, transmitter off between CLTUs) and PLOP-2 (continuous carrier) while it runs with the PLOP mode chooser. Set usrp_addr to your device (e.g. "addr=192.168.10.2"); empty uses the first USRP found. Frequencies, SCID and keys are the SOARR lab values; the keys are public test patterns.
    generate_options: qt_gui
    id: tc_loopback_usrp
    output_language: python
    title: gr-soarr TC loopback (USRP)
  states: {}

blocks:
- name: SCID
  id: variable
  parameters:
    value: '341'
  states: {}
- name: SPI
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: decim_cic
  id: variable
  parameters:
    value: '10'
  states: {}
- name: decim_rrc
  id: variable
  parameters:
    value: '2'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: s_band_center
  id: variable
  parameters:
    value: 2.185e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40*uhf_bandwidth
  states: {}
- name: sps_sync
  id: variable
  parameters:
    value: '2'
  states: {}
- name: tx_power_normal
  id: variable_qtgui_range
  parameters:
    label: Normalized Tx Gain
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.05'
  states: {}
- name: uhf_bandwidth
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '1000'
    rate: '0.01'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    log_level: warn
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    use_snr: 'True'
    w: '0.08'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '64'
    rolloff: excess_bw
    samps_per_sym: int(decim_rrc*sps_sync)
    type: cc
    w: (8e-3)/(decim_rrc*sps_sync)
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.001'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps_sync
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim_cic
    taps: firdes.low_pass(1.0, samp_rate, 15e3, 5e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: BPSK Mapping
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (1,0,1,2)
    label1: In-Phase Samples
    label2: Quarature Samples
    samp_per_symbol: '1'
    size: '256'
    srate: samp_rate
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 10e3
    fc: s_band_center
    fftsize: '256'
    gui_hint: 1,2
    name: '"after costas loop"'
    plotwaterfall: 'False'
    rate: '5'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: 40e3
    fc: s_band_center
    fftsize: '256'
    gui_hint: 0,2
    name: '"After AGC"'
    rate: '2'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: 400e3
    fc: '0'
    fftsize: '256'
    gui_hint: 0,1
    name: '"Fresh"'
    rate: '2'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: 10e3
    fc: s_band_center
    fftsize: '256'
    gui_hint: 0,0
    name: '"after costas loop"'
    showrf: 'True'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: decim_rrc
    gain: '1'
    ntaps: 11*decim_rrc*sps_sync+1
    samp_rate: samp_rate/decim_cic
    sym_rate: data_rate
    type: fir_filter_ccf
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from gnuradio import gr
      # Set the desired level (e.g., debug, info, warn, error)
      gr.logging().set_default_level(gr.log_levels.info)
    section: init_before_blocks
  states: {}
- name: soarr_data_creator_0
  id: soarr_data_creator
  parameters:
    bypass: 'False'
    control: 'False'
    data: None
    data_length_bytes: '256'
    mode: '0'
    payload_source: random
    scid: SCID
    sdls_counter: '0'
    spi: SPI
    vcid: '0'
    vcid_counter: '0'
  states: {}
- name: soarr_encapsulation_header_0
  id: soarr_encapsulation_header
  parameters:
    user_defined_field: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: uhf_bandwidth
    center_freq0: s_band_center
    dev_addr: usrp_addr
    gain0: tx_power_normal
    gain_type0: normalized
    maxoutbuf: '4096'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 15e3
    center_freq0: s_band_center
    clock_rate: 30.72e6
    clock_source0: internal
    dc_offs_enb0: auto
    dev_addr: usrp_addr
    dev_args: num_recv_frames=512,recv_buff_size=50000000
    gain0: '0.05'
    gain_type0: normalized
    iq_imbal_enb0: disabled
    otw: sc8
    rx_agc0: Disabled
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: pc_clock
    type: fc32
  states: {}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: pressed
    type: int
    value: '1'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: decode
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: decode
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '""'
  states: {}
- name: plop_mode
  id: variable_qtgui_chooser
  parameters:
    label: PLOP mode
    type: int
    num_opts: '2'
    option0: '1'
    label0: '"PLOP-1 (bursts)"'
    option1: '2'
    label1: '"PLOP-2 (continuous carrier)"'
    value: '1'
    widget: radio_buttons
    orient: Qt.QHBoxLayout
  states: {}
- name: soarr_plop_modulator_0
  id: soarr_plop_modulator
  parameters:
    mode: plop_mode
    samples_per_symbol: int(samp_rate / data_rate)
    excess_bw: '0.35'
    differential: 'True'
    acquisition_length: '64'
    tail_length: '4'
    fill_byte: '0xAA'
    amplitude: '1.0'
  states: {}
- name: soarr_key_database_0
  id: soarr_key_database
  parameters:
    auto_reset_counters: 'False'
    db_type: '0'
    role: '"tx"'
    scid: SCID
    spi: SPI
    vcid: '18'
    yaml_path: ''
  states: {}
- name: soarr_sdls_apply_0
  id: soarr_sdls_apply
  parameters:
    mode: '2'
    nonce_hex: '0000000000000000000000000000'
  states: {}
- name: soarr_tc_frame_encoder_0
  id: soarr_tc_frame_encoder
  parameters:
    scid: '0'
    vcid: '0'
  states: {}
- name: soarr_tc_frame_decoder_0
  id: soarr_tc_frame_decoder
  parameters:
    encapsulation_used: 'True'
    scid: '0'
    scid_filter_enable: 'False'
    sdls_mode: '2'
    threshold: '1'
    vcid: '0'
    vcid_filter_enable: 'False'
  states: {}
- name: soarr_key_database_1
  id: soarr_key_database
  parameters:
    auto_reset_counters: 'False'
    db_type: '0'
    role: '"rx"'
    scid: SCID
    spi: SPI
    vcid: '18'
    yaml_path: ''
  states: {}
- name: soarr_sdls_process_0
  id: soarr_sdls_process
  parameters:
    mode: '2'
    nonce_hex: '0000000000000000000000000000'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_sink_x_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_costas_loop_cc_0, '0']
- [fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_1, '0']
- [soarr_data_creator_0, out, soarr_key_database_0, in]
- [soarr_key_database_0, out, soarr_encapsulation_header_0, in]
- [soarr_sdls_process_0, out, blocks_message_debug_0_0, print]
- [uhd_usrp_source_0, '0', fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_0_0, '0']
- [variable_qtgui_msg_push_button_0, pressed, soarr_data_creator_0, ping]
- [virtual_source_3_0, '0', soarr_tc_frame_decoder_0, '0']
- [soarr_tc_frame_encoder_0, out, soarr_plop_modulator_0, in]
- [soarr_plop_modulator_0, '0', qtgui_sink_x_0_1, '0']
- [soarr_plop_modulator_0, '0', uhd_usrp_sink_0, '0']
- [soarr_encapsulation_header_0, out, soarr_sdls_apply_0, in]
- [soarr_sdls_apply_0, out, soarr_tc_frame_encoder_0, in]
- [soarr_tc_frame_decoder_0, out, soarr_key_database_1, in]
- [soarr_key_database_1, out, soarr_sdls_process_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
