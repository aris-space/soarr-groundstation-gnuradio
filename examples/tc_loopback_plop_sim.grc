options:
  parameters:
    author: gr-soarr
    description: 'Full TX -> RX chain at signal level without an SDR: plop_modulator turns CLTUs into differential BPSK, a channel model adds noise and a frequency offset, and the RX DSP chain of the USRP examples demodulates it. Switch between PLOP-1 (bursts) and PLOP-2 (continuous carrier) while it runs. SDLS encryption and authentication are on.'
    generate_options: qt_gui
    id: tc_loopback_plop_sim
    output_language: python
    title: gr-soarr TC loopback with switchable PLOP (software only)
  states: {}

blocks:
- name: SCID
  id: variable
  parameters:
    value: '341'
  states: {}
- name: SPI
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: decim_cic
  id: variable
  parameters:
    value: '10'
  states: {}
- name: decim_rrc
  id: variable
  parameters:
    value: '2'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: s_band_center
  id: variable
  parameters:
    value: 2.185e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40*uhf_bandwidth
  states: {}
- name: sps_sync
  id: variable
  parameters:
    value: '2'
  states: {}
- name: uhf_bandwidth
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '1000'
    rate: '0.01'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    log_level: warn
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("start")
    period: '1000'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    use_snr: 'True'
    w: '0.08'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '64'
    rolloff: excess_bw
    samps_per_sym: int(decim_rrc*sps_sync)
    type: cc
    w: (8e-3)/(decim_rrc*sps_sync)
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.001'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps_sync
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim_cic
    taps: firdes.low_pass(1.0, samp_rate, 15e3, 5e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: BPSK Mapping
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (1,0,1,2)
    label1: In-Phase Samples
    label2: Quarature Samples
    samp_per_symbol: '1'
    size: '256'
    srate: samp_rate
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 10e3
    fc: s_band_center
    fftsize: '256'
    gui_hint: 1,2
    name: '"after costas loop"'
    plotwaterfall: 'False'
    rate: '5'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: 40e3
    fc: s_band_center
    fftsize: '256'
    gui_hint: 0,2
    name: '"After AGC"'
    rate: '2'
    showrf: 'True'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: decim_rrc
    gain: '1'
    ntaps: 11*decim_rrc*sps_sync+1
    samp_rate: samp_rate/decim_cic
    sym_rate: data_rate
    type: fir_filter_ccf
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from gnuradio import gr
      # Set the desired level (e.g., debug, info, warn, error)
      gr.logging().set_default_level(gr.log_levels.info)
    section: init_before_blocks
  states: {}
- name: soarr_data_creator_0
  id: soarr_data_creator
  parameters:
    bypass: 'False'
    control: 'False'
    data: None
    data_length_bytes: '256'
    mode: '0'
    payload_source: random
    scid: SCID
    sdls_counter: '0'
    spi: SPI
    vcid: '0'
    vcid_counter: '0'
  states: {}
- name: soarr_encapsulation_header_0
  id: soarr_encapsulation_header
  parameters:
    user_defined_field: '0'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: decode
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: decode
  states: {}
- name: plop_mode
  id: variable_qtgui_chooser
  parameters:
    label: PLOP mode
    type: int
    num_opts: '2'
    option0: '1'
    label0: '"PLOP-1 (bursts)"'
    option1: '2'
    label1: '"PLOP-2 (continuous carrier)"'
    value: '2'
    widget: radio_buttons
    orient: Qt.QHBoxLayout
  states: {}
- name: channel_noise
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: soarr_plop_modulator_0
  id: soarr_plop_modulator
  parameters:
    mode: plop_mode
    samples_per_symbol: int(samp_rate / data_rate)
    excess_bw: '0.35'
    differential: 'True'
    acquisition_length: '64'
    tail_length: '4'
    fill_byte: '0xAA'
    amplitude: '1.0'
  states: {}
- name: blocks_throttle2_sdr
  id: blocks_throttle2
  parameters:
    type: complex
    samples_per_second: samp_rate
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    noise_voltage: channel_noise
    freq_offset: 100 / samp_rate
    epsilon: '1.0'
    taps: '1.0'
    seed: '0'
  states: {}
- name: soarr_encapsulation_parser_0
  id: soarr_encapsulation_parser
  parameters: {}
  states: {}
- name: soarr_key_database_0
  id: soarr_key_database
  parameters:
    auto_reset_counters: 'False'
    db_type: '0'
    role: '"tx"'
    scid: SCID
    spi: SPI
    vcid: '18'
    yaml_path: ''
  states: {}
- name: soarr_sdls_apply_0
  id: soarr_sdls_apply
  parameters:
    mode: '3'
    nonce_hex: '0000000000000000000000000000'
  states: {}
- name: soarr_tc_frame_encoder_0
  id: soarr_tc_frame_encoder
  parameters:
    scid: '0'
    vcid: '0'
  states: {}
- name: soarr_tc_frame_decoder_0
  id: soarr_tc_frame_decoder
  parameters:
    encapsulation_used: 'True'
    scid: '0'
    scid_filter_enable: 'False'
    sdls_mode: '3'
    threshold: '1'
    vcid: '0'
    vcid_filter_enable: 'False'
  states: {}
- name: soarr_key_database_1
  id: soarr_key_database
  parameters:
    auto_reset_counters: 'False'
    db_type: '0'
    role: '"rx"'
    scid: SCID
    spi: SPI
    vcid: '18'
    yaml_path: ''
  states: {}
- name: soarr_sdls_process_0
  id: soarr_sdls_process
  parameters:
    mode: '3'
    nonce_hex: '0000000000000000000000000000'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_message_strobe_0, strobe, soarr_data_creator_0, ping]
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_costas_loop_cc_0, '0']
- [fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_1, '0']
- [soarr_data_creator_0, out, soarr_key_database_0, in]
- [soarr_key_database_0, out, soarr_encapsulation_header_0, in]
- [soarr_encapsulation_parser_0, out, blocks_message_debug_0_0, print]
- [virtual_source_3_0, '0', soarr_tc_frame_decoder_0, '0']
- [soarr_tc_frame_encoder_0, out, soarr_plop_modulator_0, in]
- [soarr_plop_modulator_0, '0', blocks_throttle2_sdr, '0']
- [blocks_throttle2_sdr, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', fir_filter_xxx_0, '0']
- [soarr_sdls_process_0, out, soarr_encapsulation_parser_0, in]
- [soarr_encapsulation_header_0, out, soarr_sdls_apply_0, in]
- [soarr_sdls_apply_0, out, soarr_tc_frame_encoder_0, in]
- [soarr_tc_frame_decoder_0, out, soarr_key_database_1, in]
- [soarr_key_database_1, out, soarr_sdls_process_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
