options:
  parameters:
    author: gr-soarr
    description: 'Runs the full TC chain without any SDR: data_creator -> SDLS -> TC frame -> CLTU -> byte stream -> CLTU detection -> frame reassembly -> SDLS verification and decryption -> encapsulation header removal. SDLS encryption and authentication are both on, and frames go out as PLOP-1 bursts. A new frame is sent every second; each received payload is printed.'
    generate_options: no_gui
    id: tc_loopback_sim
    output_language: python
    title: gr-soarr TC loopback (software only)
  states: {}

blocks:
- name: SCID
  id: variable
  parameters:
    value: '341'
  states: {}
- name: SPI
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    log_level: warn
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("start")
    period: '1000'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: 'Software-only loopback: the byte stream goes straight from TX to RX, no SDR.'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from gnuradio import gr
      # Set the desired level (e.g., debug, info, warn, error)
      gr.logging().set_default_level(gr.log_levels.info)
    section: init_before_blocks
  states: {}
- name: soarr_data_creator_0
  id: soarr_data_creator
  parameters:
    bypass: 'False'
    control: 'False'
    data: None
    data_length_bytes: '256'
    mode: '0'
    payload_source: random
    scid: SCID
    sdls_counter: '0'
    spi: SPI
    vcid: '0'
    vcid_counter: '0'
  states: {}
- name: soarr_encapsulation_header_0
  id: soarr_encapsulation_header
  parameters:
    user_defined_field: '0'
  states: {}
- name: soarr_encapsulation_parser_0
  id: soarr_encapsulation_parser
  parameters: {}
  states: {}
- name: soarr_cltu_burst_builder_0
  id: soarr_cltu_burst_builder
  parameters:
    acquisition_length: '64'
    tail_length: '4'
    fill_byte: '0xAA'
    diff_encoded: 'False'
    max_burst_pdus: '64'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    type: byte
    tag: packet_len
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: soarr_key_database_0
  id: soarr_key_database
  parameters:
    auto_reset_counters: 'False'
    db_type: '0'
    role: '"tx"'
    scid: SCID
    spi: SPI
    vcid: '18'
    yaml_path: ''
  states: {}
- name: soarr_sdls_apply_0
  id: soarr_sdls_apply
  parameters:
    mode: '3'
    nonce_hex: '0000000000000000000000000000'
  states: {}
- name: soarr_tc_frame_encoder_0
  id: soarr_tc_frame_encoder
  parameters:
    scid: '0'
    vcid: '0'
  states: {}
- name: soarr_tc_frame_decoder_0
  id: soarr_tc_frame_decoder
  parameters:
    encapsulation_used: 'True'
    scid: '0'
    scid_filter_enable: 'False'
    sdls_mode: '3'
    threshold: '1'
    vcid: '0'
    vcid_filter_enable: 'False'
  states: {}
- name: soarr_key_database_1
  id: soarr_key_database
  parameters:
    auto_reset_counters: 'False'
    db_type: '0'
    role: '"rx"'
    scid: SCID
    spi: SPI
    vcid: '18'
    yaml_path: ''
  states: {}
- name: soarr_sdls_process_0
  id: soarr_sdls_process
  parameters:
    mode: '3'
    nonce_hex: '0000000000000000000000000000'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, soarr_data_creator_0, ping]
- [soarr_data_creator_0, out, soarr_key_database_0, in]
- [soarr_key_database_0, out, soarr_encapsulation_header_0, in]
- [soarr_encapsulation_parser_0, out, blocks_message_debug_0_0, print]
- [soarr_sdls_process_0, out, soarr_encapsulation_parser_0, in]
- [soarr_tc_frame_encoder_0, out, soarr_cltu_burst_builder_0, in]
- [soarr_cltu_burst_builder_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', soarr_tc_frame_decoder_0, '0']
- [soarr_encapsulation_header_0, out, soarr_sdls_apply_0, in]
- [soarr_sdls_apply_0, out, soarr_tc_frame_encoder_0, in]
- [soarr_tc_frame_decoder_0, out, soarr_key_database_1, in]
- [soarr_key_database_1, out, soarr_sdls_process_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
