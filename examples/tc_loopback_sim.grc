options:
  parameters:
    author: gr-soarr
    description: 'Runs the full TC chain without any SDR: data_creator -> SDLS -> TC frame -> CLTU -> byte stream -> CLTU detection -> frame reassembly -> SDLS verification and decryption -> encapsulation header removal. SDLS encryption and authentication are both on. A new frame is sent every second; each received payload is printed.'
    generate_options: no_gui
    id: tc_loopback_sim
    output_language: python
    title: gr-soarr TC loopback (software only)
  states: {}

blocks:
- name: SCID
  id: variable
  parameters:
    value: '341'
  states: {}
- name: SPI
  id: variable
  parameters:
    value: '1'
  states: {}
- name: crc
  id: variable_struct
  parameters:
    field0: '''Size'''
    field1: '''Polynomial'''
    field2: '''initRegisterValue'''
    field3: '''finalXorValue'''
    value0: '16'
    value1: '0x1021'
    value2: '0xFFFF'
    value3: '0xFFFF'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: decim_cic
  id: variable
  parameters:
    value: '10'
  states: {}
- name: decim_rrc
  id: variable
  parameters:
    value: '2'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: s_band_center
  id: variable
  parameters:
    value: 2.185e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40*uhf_bandwidth
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 400e3
  states: {state: disabled}
- name: sps_sync
  id: variable
  parameters:
    value: '2'
  states: {}
- name: uhf_bandwidth
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: uhf_center
  id: variable
  parameters:
    value: 437.065e6
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    log_level: warn
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters:
    log_level: debug
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("start")
    period: '1000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maxoutbuf: '4096'
    samples_per_second: 50e3
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1110101110010000'
    tagname: start
    threshold: '1'
    type: byte
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    final_xor: crc.finalXorValue
    initial_value: crc.initRegisterValue
    input_reflected: 'False'
    num_bits: crc.Size
    poly: crc.Polynomial
    result_reflected: 'False'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    final_xor: crc.finalXorValue
    initial_value: crc.initRegisterValue
    input_reflected: 'False'
    num_bits: crc.Size
    poly: crc.Polynomial
    result_reflected: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: 'Software-only loopback: the byte stream goes straight from TX to RX, no SDR.'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from gnuradio import gr
      # Set the desired level (e.g., debug, info, warn, error)
      gr.logging().set_default_level(gr.log_levels.info)
    section: init_before_blocks
  states: {}
- name: soarr_acquisition_idle_sequencer_0
  id: soarr_acquisition_idle_sequencer
  parameters:
    acquisition_sequence: '[170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170]'
    diff_encoded: 'False'
    idle_sequence: '170'
    initial_acquisition: 'True'
    max_idle_chunk: '64'
    maxoutbuf: '4096'
    tsb_tag_name: packet_len
  states: {}
- name: soarr_bch_encoder_0
  id: soarr_bch_encoder
  parameters:
    polynomial: '197'
  states: {}
- name: soarr_ccsds_reader_0
  id: soarr_ccsds_reader
  parameters:
    data_type: '0'
    encapsulation_used: 'True'
    sdls_type: '3'
  states: {}
- name: soarr_ccsds_receiver_0
  id: soarr_ccsds_receiver
  parameters:
    field_type: '0'
    fixed_byte_length: '0'
    message_type: '0'
    scid: '0'
    scid_filter_enable: 'False'
    vcid: '0'
    vcid_filter_enable: 'False'
  states: {}
- name: soarr_cltu_deframer_0
  id: soarr_cltu_deframer
  parameters:
    input_packed: 'False'
    output_packed: 'True'
    payload_bytes: '8'
    start_sequence: '60304'
    tag_name: start
    tail_sequence: '14251014049101104505'
    threshold: '2'
  states: {}
- name: soarr_cltu_framer_0
  id: soarr_cltu_framer
  parameters:
    start_sequence: '60304'
    tail_sequence: '14251014049101104505'
  states: {}
- name: soarr_data_creator_0
  id: soarr_data_creator
  parameters:
    bypass: 'False'
    control: 'False'
    data: None
    data_length_bytes: '256'
    mode: '0'
    payload_source: random
    scid: SCID
    sdls_counter: '0'
    spi: SPI
    vcid: '0'
    vcid_counter: '0'
  states: {}
- name: soarr_db_client_0
  id: soarr_db_client
  parameters:
    auth_key: FFEEDDCCBBAA99887766554433221100FFEEDDCCBBAA99887766554433221100
    auto_reset_counters: 'False'
    crypt_key: 00112233445566778899AABBCCDDEEFF00112233445566778899AABBCCDDEEFF
    forward_body: 'True'
    ip: 127.0.0.1
    key_state_auth: active
    key_state_enc: active
    port: '80'
    scid: SCID
    sdls_counter: '0'
    spi: SPI
    type: '0'
    vcid: '18'
    vcid_counter: '0'
    yaml_path: ''
  states: {}
- name: soarr_db_client_0_0
  id: soarr_db_client
  parameters:
    auth_key: FFEEDDCCBBAA99887766554433221100FFEEDDCCBBAA99887766554433221100
    auto_reset_counters: 'False'
    crypt_key: 00112233445566778899AABBCCDDEEFF00112233445566778899AABBCCDDEEFF
    forward_body: 'True'
    ip: 127.0.0.1
    key_state_auth: active
    key_state_enc: active
    port: '80'
    scid: SCID
    sdls_counter: '0'
    spi: SPI
    type: '0'
    vcid: '18'
    vcid_counter: '0'
    yaml_path: ''
  states: {}
- name: soarr_encapsulation_header_0
  id: soarr_encapsulation_header
  parameters:
    user_defined_field: '0'
  states: {}
- name: soarr_inject_db_0
  id: soarr_inject_db
  parameters: {}
  states: {}
- name: soarr_inject_db_0_0
  id: soarr_inject_db
  parameters: {}
  states: {}
- name: soarr_lfsr_scrambler_0
  id: soarr_lfsr_scrambler
  parameters:
    register_length: '8'
    seed: '255'
  states: {}
- name: soarr_sdls_authentication_0
  id: soarr_sdls_authentication
  parameters:
    authentication_state: 'True'
    nonce_hex: '0000000000000000000000000000'
  states: {}
- name: soarr_sdls_authentication_verify_0
  id: soarr_sdls_authentication_verify
  parameters:
    authentication_state: 'True'
    nonce_hex: '0000000000000000000000000000'
  states: {}
- name: soarr_sdls_decryption_0
  id: soarr_sdls_decryption
  parameters:
    decryption_state: 'True'
    nonce_hex: '0000000000000000000000000000'
  states: {}
- name: soarr_sdls_encryption_0
  id: soarr_sdls_encryption
  parameters:
    encryption_state: 'True'
    nonce_hex: '0000000000000000000000000000'
  states: {}
- name: soarr_sdls_header_0
  id: soarr_sdls_header
  parameters: {}
  states: {}
- name: soarr_tc_primary_header_0
  id: soarr_tc_primary_header
  parameters:
    is_crc_used: 'True'
    scid: '0'
    vcid: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: to_encoding
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: to_sdls
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: virtual_channel
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: to_encoding
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: to_sdls
  states: {}
- name: soarr_encapsulation_parser_0
  id: soarr_encapsulation_parser
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, soarr_data_creator_0, ping]
- [digital_correlate_access_code_tag_xx_0, '0', soarr_cltu_deframer_0, '0']
- [digital_crc_append_0, out, virtual_sink_0, '0']
- [digital_crc_check_0, fail, blocks_message_debug_0_0_0, log]
- [digital_crc_check_0, ok, soarr_ccsds_reader_0, ccsds]
- [soarr_acquisition_idle_sequencer_0, '0', blocks_throttle2_0, '0']
- [soarr_bch_encoder_0, codewords, soarr_cltu_framer_0, in]
- [soarr_ccsds_reader_0, debug, soarr_inject_db_0_0, in]
- [soarr_ccsds_receiver_0, out, digital_crc_check_0, in]
- [soarr_cltu_deframer_0, out, blocks_message_debug_0_0_0, log]
- [soarr_cltu_deframer_0, out, soarr_ccsds_receiver_0, in]
- [soarr_cltu_framer_0, out, soarr_acquisition_idle_sequencer_0, in]
- [soarr_data_creator_0, out, soarr_inject_db_0, in]
- [soarr_db_client_0, db_callback, soarr_inject_db_0, db_callback]
- [soarr_db_client_0_0, db_callback, soarr_inject_db_0_0, db_callback]
- [soarr_encapsulation_header_0, out, virtual_sink_2, '0']
- [soarr_inject_db_0, db_call, soarr_db_client_0, db_call]
- [soarr_inject_db_0, out, soarr_encapsulation_header_0, in]
- [soarr_inject_db_0_0, db_call, soarr_db_client_0_0, db_call]
- [soarr_inject_db_0_0, out, soarr_sdls_authentication_verify_0, in]
- [soarr_lfsr_scrambler_0, out, soarr_bch_encoder_0, message]
- [soarr_sdls_authentication_0, out, soarr_sdls_header_0, in]
- [soarr_sdls_authentication_verify_0, out, soarr_sdls_decryption_0, in]
- [soarr_encapsulation_parser_0, out, blocks_message_debug_0_0, print]
- [soarr_sdls_encryption_0, out, soarr_sdls_authentication_0, in]
- [soarr_sdls_header_0, out, soarr_tc_primary_header_0, in]
- [soarr_tc_primary_header_0, out, digital_crc_append_0, in]
- [virtual_source_0, '0', soarr_lfsr_scrambler_0, in]
- [virtual_source_1, '0', soarr_sdls_encryption_0, in]
- [soarr_sdls_decryption_0, out, soarr_encapsulation_parser_0, in]
- [blocks_throttle2_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_tag_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
