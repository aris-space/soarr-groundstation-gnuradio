options:
  parameters:
    author: gr-soarr
    description: Builds SDLS-protected CCSDS TC frames and transmits them as BPSK via a USRP. Switch between PLOP-1 (bursts, transmitter off between CLTUs) and PLOP-2 (continuous carrier) while it runs with the PLOP mode chooser. Set usrp_addr to your device (e.g. "addr=192.168.10.2"); empty uses the first USRP found. Frequencies, SCID and keys are the SOARR lab values; the keys are public test patterns.
    generate_options: qt_gui
    id: tc_tx_usrp
    output_language: python
    title: gr-soarr TC transmitter (USRP)
  states: {}

blocks:
- name: SCID
  id: variable
  parameters:
    value: '341'
  states: {}
- name: SPI
  id: variable
  parameters:
    value: '1'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: s_band_center
  id: variable
  parameters:
    value: 2.185e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40*uhf_bandwidth
  states: {}
- name: tx_power_normal
  id: variable_qtgui_range
  parameters:
    label: Normalized Tx Gain
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.05'
  states: {}
- name: uhf_bandwidth
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: BPSK Mapping
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: 10e3
    fc: s_band_center
    fftsize: '256'
    gui_hint: 0,0
    name: '"after costas loop"'
    showrf: 'True'
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from gnuradio import gr
      # Set the desired level (e.g., debug, info, warn, error)
      gr.logging().set_default_level(gr.log_levels.info)
    section: init_before_blocks
  states: {}
- name: soarr_data_creator_0
  id: soarr_data_creator
  parameters:
    bypass: 'False'
    control: 'False'
    data: None
    data_length_bytes: '256'
    mode: '0'
    payload_source: random
    scid: SCID
    sdls_counter: '0'
    spi: SPI
    vcid: '0'
    vcid_counter: '0'
  states: {}
- name: soarr_encapsulation_header_0
  id: soarr_encapsulation_header
  parameters:
    user_defined_field: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: uhf_bandwidth
    center_freq0: s_band_center
    dev_addr: usrp_addr
    gain0: tx_power_normal
    gain_type0: normalized
    maxoutbuf: '4096'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: pressed
    type: int
    value: '1'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '""'
  states: {}
- name: plop_mode
  id: variable_qtgui_chooser
  parameters:
    label: PLOP mode
    type: int
    num_opts: '2'
    option0: '1'
    label0: '"PLOP-1 (bursts)"'
    option1: '2'
    label1: '"PLOP-2 (continuous carrier)"'
    value: '1'
    widget: radio_buttons
    orient: Qt.QHBoxLayout
  states: {}
- name: soarr_plop_modulator_0
  id: soarr_plop_modulator
  parameters:
    mode: plop_mode
    samples_per_symbol: int(samp_rate / data_rate)
    excess_bw: '0.35'
    differential: 'True'
    acquisition_length: '64'
    tail_length: '4'
    fill_byte: '0xAA'
    amplitude: '1.0'
  states: {}
- name: soarr_key_database_0
  id: soarr_key_database
  parameters:
    auto_reset_counters: 'False'
    db_type: '0'
    role: '"tx"'
    scid: SCID
    spi: SPI
    vcid: '18'
    yaml_path: ''
  states: {}
- name: soarr_sdls_apply_0
  id: soarr_sdls_apply
  parameters:
    mode: '2'
    nonce_hex: '0000000000000000000000000000'
  states: {}
- name: soarr_tc_frame_encoder_0
  id: soarr_tc_frame_encoder
  parameters:
    scid: '0'
    vcid: '0'
  states: {}

connections:
- [soarr_data_creator_0, out, soarr_key_database_0, in]
- [soarr_key_database_0, out, soarr_encapsulation_header_0, in]
- [variable_qtgui_msg_push_button_0, pressed, soarr_data_creator_0, ping]
- [soarr_tc_frame_encoder_0, out, soarr_plop_modulator_0, in]
- [soarr_plop_modulator_0, '0', qtgui_sink_x_0_1, '0']
- [soarr_plop_modulator_0, '0', uhd_usrp_sink_0, '0']
- [soarr_encapsulation_header_0, out, soarr_sdls_apply_0, in]
- [soarr_sdls_apply_0, out, soarr_tc_frame_encoder_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
