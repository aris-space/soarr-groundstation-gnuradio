options:
  parameters:
    author: gr-soarr
    description: Builds SDLS-protected CCSDS TC frames and transmits them as BPSK via a USRP. Set usrp_addr to your device (e.g. "addr=192.168.10.2"); empty uses the first USRP found. Frequencies, SCID and keys are the SOARR lab values; the keys are public test patterns.
    generate_options: qt_gui
    id: tc_tx_usrp
    output_language: python
    title: gr-soarr TC transmitter (USRP)
  states: {}

blocks:
- name: CCSDS_BPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: SCID
  id: variable
  parameters:
    value: '341'
  states: {}
- name: SPI
  id: variable
  parameters:
    value: '1'
  states: {}
- name: crc
  id: variable_struct
  parameters:
    field0: '''Size'''
    field1: '''Polynomial'''
    field2: '''initRegisterValue'''
    field3: '''finalXorValue'''
    value0: '16'
    value1: '0x1021'
    value2: '0xFFFF'
    value3: '0xFFFF'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: s_band_center
  id: variable
  parameters:
    value: 2.185e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40*uhf_bandwidth
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 400e3
  states: {state: disabled}
- name: tx_power_normal
  id: variable_qtgui_range
  parameters:
    label: Normalized Tx Gain
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.05'
  states: {}
- name: uhf_bandwidth
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: uhf_center
  id: variable
  parameters:
    value: 437.065e6
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("start")
    period: '500'
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 40* 8
    lengthtagname: packet_len
    maxoutbuf: '4096'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maxoutbuf: '4096'
    samples_per_second: samp_rate/40
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: CCSDS_BPSK
    differential: 'True'
    excess_bw: '0.35'
    maxoutbuf: '4096'
    samples_per_symbol: '40'
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    final_xor: crc.finalXorValue
    initial_value: crc.initRegisterValue
    input_reflected: 'False'
    num_bits: crc.Size
    poly: crc.Polynomial
    result_reflected: 'False'
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: BPSK Mapping
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: 10e3
    fc: s_band_center
    fftsize: '256'
    gui_hint: 0,0
    name: '"after costas loop"'
    showrf: 'True'
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from gnuradio import gr
      # Set the desired level (e.g., debug, info, warn, error)
      gr.logging().set_default_level(gr.log_levels.info)
    section: init_before_blocks
  states: {}
- name: soarr_acquisition_idle_sequencer_0
  id: soarr_acquisition_idle_sequencer
  parameters:
    acquisition_sequence: '[170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170, 170]'
    diff_encoded: 'True'
    idle_sequence: '170'
    initial_acquisition: 'True'
    max_idle_chunk: '64'
    maxoutbuf: '4096'
    tsb_tag_name: packet_len
  states: {}
- name: soarr_bch_encoder_0
  id: soarr_bch_encoder
  parameters:
    polynomial: '197'
  states: {}
- name: soarr_cltu_framer_0
  id: soarr_cltu_framer
  parameters:
    start_sequence: '60304'
    tail_sequence: '14251014049101104505'
  states: {}
- name: soarr_data_creator_0
  id: soarr_data_creator
  parameters:
    bypass: 'False'
    control: 'False'
    data: None
    data_length_bytes: '256'
    mode: '0'
    payload_source: random
    scid: SCID
    sdls_counter: '0'
    spi: SPI
    vcid: '0'
    vcid_counter: '0'
  states: {}
- name: soarr_db_client_0
  id: soarr_db_client
  parameters:
    auth_key: FFEEDDCCBBAA99887766554433221100FFEEDDCCBBAA99887766554433221100
    auto_reset_counters: 'False'
    crypt_key: 00112233445566778899AABBCCDDEEFF00112233445566778899AABBCCDDEEFF
    forward_body: 'True'
    ip: 127.0.0.1
    key_state_auth: active
    key_state_enc: active
    port: '80'
    scid: SCID
    sdls_counter: '0'
    spi: SPI
    type: '0'
    vcid: '18'
    vcid_counter: '0'
    yaml_path: ''
  states: {}
- name: soarr_encapsulation_header_0
  id: soarr_encapsulation_header
  parameters:
    user_defined_field: '0'
  states: {}
- name: soarr_inject_db_0
  id: soarr_inject_db
  parameters: {}
  states: {}
- name: soarr_lfsr_scrambler_0
  id: soarr_lfsr_scrambler
  parameters:
    register_length: '8'
    seed: '255'
  states: {}
- name: soarr_sdls_authentication_0
  id: soarr_sdls_authentication
  parameters:
    authentication_state: 'True'
    nonce_hex: '0000000000000000000000000000'
  states: {}
- name: soarr_sdls_encryption_0
  id: soarr_sdls_encryption
  parameters:
    encryption_state: 'False'
    nonce_hex: '0000000000000000000000000000'
  states: {}
- name: soarr_sdls_header_0
  id: soarr_sdls_header
  parameters: {}
  states: {}
- name: soarr_tc_primary_header_0
  id: soarr_tc_primary_header
  parameters:
    is_crc_used: 'True'
    scid: '0'
    vcid: '0'
  states: {}
- name: trigger_acq
  id: variable_qtgui_msg_push_button
  parameters:
    label: Trigger Aquisition Sequence
    msgName: pressed
    type: int
    value: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: uhf_bandwidth
    center_freq0: s_band_center
    dev_addr: usrp_addr
    gain0: tx_power_normal
    gain_type0: normalized
    len_tag_name: '"packet_len"'
    maxoutbuf: '4096'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: pressed
    type: int
    value: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: to_encoding
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: to_sdls
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: virtual_channel
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: to_encoding
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: to_sdls
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '""'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, soarr_data_creator_0, ping]
- [blocks_tagged_stream_multiply_length_0, '0', qtgui_sink_x_0_1, '0']
- [blocks_tagged_stream_multiply_length_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_crc_append_0, out, virtual_sink_0, '0']
- [soarr_acquisition_idle_sequencer_0, '0', blocks_throttle2_0, '0']
- [soarr_bch_encoder_0, codewords, soarr_cltu_framer_0, in]
- [soarr_cltu_framer_0, out, soarr_acquisition_idle_sequencer_0, in]
- [soarr_data_creator_0, out, soarr_inject_db_0, in]
- [soarr_db_client_0, db_callback, soarr_inject_db_0, db_callback]
- [soarr_encapsulation_header_0, out, virtual_sink_2, '0']
- [soarr_inject_db_0, db_call, soarr_db_client_0, db_call]
- [soarr_inject_db_0, out, soarr_encapsulation_header_0, in]
- [soarr_lfsr_scrambler_0, out, soarr_bch_encoder_0, message]
- [soarr_sdls_authentication_0, out, soarr_sdls_header_0, in]
- [soarr_sdls_encryption_0, out, soarr_sdls_authentication_0, in]
- [soarr_sdls_header_0, out, soarr_tc_primary_header_0, in]
- [soarr_tc_primary_header_0, out, digital_crc_append_0, in]
- [trigger_acq, pressed, soarr_acquisition_idle_sequencer_0, trigger_acq]
- [variable_qtgui_msg_push_button_0, pressed, soarr_data_creator_0, ping]
- [virtual_source_0, '0', soarr_lfsr_scrambler_0, in]
- [virtual_source_1, '0', soarr_sdls_encryption_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
