options:
  parameters:
    author: gr-soarr
    description: Receives BPSK from a USRP, recovers CLTUs and TC frames, verifies and decrypts them. Set usrp_addr to your device (e.g. "addr=192.168.10.2"); empty uses the first USRP found. Frequencies, SCID and keys are the SOARR lab values; the keys are public test patterns.
    generate_options: qt_gui
    id: tc_rx_usrp
    output_language: python
    title: gr-soarr TC receiver (USRP)
  states: {}

blocks:
- name: CCSDS_BPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: SCID
  id: variable
  parameters:
    value: '341'
  states: {}
- name: SPI
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: crc
  id: variable_struct
  parameters:
    field0: '''Size'''
    field1: '''Polynomial'''
    field2: '''initRegisterValue'''
    field3: '''finalXorValue'''
    value0: '16'
    value1: '0x1021'
    value2: '0xFFFF'
    value3: '0xFFFF'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: decim_cic
  id: variable
  parameters:
    value: '10'
  states: {}
- name: decim_rrc
  id: variable
  parameters:
    value: '2'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: s_band_center
  id: variable
  parameters:
    value: 2.185e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40*uhf_bandwidth
  states: {}
- name: sps_sync
  id: variable
  parameters:
    value: '2'
  states: {}
- name: tx_power_normal
  id: variable_qtgui_range
  parameters:
    label: Normalized Tx Gain
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.05'
  states: {}
- name: uhf_bandwidth
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '1000'
    rate: '0.01'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    log_level: warn
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters:
    log_level: debug
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1110101110010000'
    tagname: start
    threshold: '1'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    use_snr: 'True'
    w: '0.08'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    final_xor: crc.finalXorValue
    initial_value: crc.initRegisterValue
    input_reflected: 'False'
    num_bits: crc.Size
    poly: crc.Polynomial
    result_reflected: 'False'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '64'
    rolloff: excess_bw
    samps_per_sym: int(decim_rrc*sps_sync)
    type: cc
    w: (8e-3)/(decim_rrc*sps_sync)
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.001'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps_sync
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim_cic
    taps: firdes.low_pass(1.0, samp_rate, 15e3, 5e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: Trasmitted
    label2: Received
    nconnections: '2'
    size: '256'
    type: complex
  states: {state: disabled}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (1,0,1,2)
    label1: In-Phase Samples
    label2: Quarature Samples
    samp_per_symbol: '1'
    size: '256'
    srate: samp_rate
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 10e3
    fc: s_band_center
    fftsize: '256'
    gui_hint: 1,2
    name: '"after costas loop"'
    plotwaterfall: 'False'
    rate: '5'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: 40e3
    fc: s_band_center
    fftsize: '256'
    gui_hint: 0,2
    name: '"After AGC"'
    rate: '2'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: 400e3
    fc: '0'
    fftsize: '256'
    gui_hint: 0,1
    name: '"Fresh"'
    rate: '2'
    showrf: 'True'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: decim_rrc
    gain: '1'
    ntaps: 11*decim_rrc*sps_sync+1
    samp_rate: samp_rate/decim_cic
    sym_rate: data_rate
    type: fir_filter_ccf
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from gnuradio import gr
      # Set the desired level (e.g., debug, info, warn, error)
      gr.logging().set_default_level(gr.log_levels.info)
    section: init_before_blocks
  states: {}
- name: soarr_ccsds_reader_0
  id: soarr_ccsds_reader
  parameters:
    data_type: '0'
    encapsulation_used: 'True'
    sdls_type: '2'
  states: {}
- name: soarr_ccsds_receiver_0
  id: soarr_ccsds_receiver
  parameters:
    field_type: '0'
    fixed_byte_length: '0'
    message_type: '0'
    scid: '0'
    scid_filter_enable: 'False'
    vcid: '0'
    vcid_filter_enable: 'False'
  states: {}
- name: soarr_cltu_deframer_0
  id: soarr_cltu_deframer
  parameters:
    input_packed: 'False'
    output_packed: 'True'
    payload_bytes: '8'
    start_sequence: '60304'
    tag_name: start
    tail_sequence: '14251014049101104505'
    threshold: '2'
  states: {}
- name: soarr_db_client_0_0
  id: soarr_db_client
  parameters:
    auth_key: FFEEDDCCBBAA99887766554433221100FFEEDDCCBBAA99887766554433221100
    auto_reset_counters: 'False'
    crypt_key: 00112233445566778899AABBCCDDEEFF00112233445566778899AABBCCDDEEFF
    forward_body: 'True'
    ip: 127.0.0.1
    key_state_auth: active
    key_state_enc: active
    port: '80'
    scid: SCID
    sdls_counter: '0'
    spi: SPI
    type: '0'
    vcid: '18'
    vcid_counter: '0'
    yaml_path: ''
  states: {}
- name: soarr_inject_db_0_0
  id: soarr_inject_db
  parameters:
    role: '"rx"'
  states: {}
- name: soarr_sdls_authentication_verify_0
  id: soarr_sdls_authentication_verify
  parameters:
    authentication_state: 'True'
    nonce_hex: '0000000000000000000000000000'
  states: {}
- name: soarr_sdls_decryption_0
  id: soarr_sdls_decryption
  parameters:
    decryption_state: 'False'
    nonce_hex: '0000000000000000000000000000'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 15e3
    center_freq0: s_band_center
    clock_rate: 30.72e6
    clock_source0: internal
    dc_offs_enb0: auto
    dev_addr: usrp_addr
    dev_args: num_recv_frames=512,recv_buff_size=50000000
    gain0: '0.05'
    gain_type0: normalized
    iq_imbal_enb0: disabled
    otw: sc8
    rx_agc0: Disabled
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: decode
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: decode
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '""'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_sink_x_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', soarr_cltu_deframer_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_sink_x_0, '0']
- [digital_crc_check_0, fail, blocks_message_debug_0_0_0, log]
- [digital_crc_check_0, ok, soarr_ccsds_reader_0, ccsds]
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_costas_loop_cc_0, '0']
- [fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_1, '0']
- [soarr_ccsds_reader_0, debug, soarr_inject_db_0_0, in]
- [soarr_ccsds_receiver_0, out, digital_crc_check_0, in]
- [soarr_cltu_deframer_0, out, blocks_message_debug_0_0_0, log]
- [soarr_cltu_deframer_0, out, soarr_ccsds_receiver_0, in]
- [soarr_db_client_0_0, db_callback, soarr_inject_db_0_0, db_callback]
- [soarr_inject_db_0_0, db_call, soarr_db_client_0_0, db_call]
- [soarr_inject_db_0_0, out, soarr_sdls_authentication_verify_0, in]
- [soarr_sdls_authentication_verify_0, out, soarr_sdls_decryption_0, in]
- [soarr_sdls_decryption_0, out, blocks_message_debug_0_0, print]
- [uhd_usrp_source_0, '0', fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_0_0, '0']
- [virtual_source_3_0, '0', digital_correlate_access_code_tag_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
